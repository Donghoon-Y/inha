options:
  parameters:
    generate_options: no_gui
    id: SatelliteSystemPractice
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\whdyd\Desktop\Practice\audio\satnogs_13951160_2026-05-01T05-59-56.ogg
    repeat: 'False'
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    file: C:\Users\whdyd\sat\decoded\SatelliteSystemPractice.kiss
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    norad: '39444'
    options: '" --f_offset 12000 --syncword_threshold 16"'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, satellites_kiss_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
